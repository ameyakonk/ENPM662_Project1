Commit message: Added mini_car/controller_manager in urdf file

File: urdf/project1_integrated.urdf (robot description, URDF)
Before this commit: robot enpm662_proj1_urdf, 9 links, 8 joints
Joints:
- joint lidar_joint: origin xyz=0 0 0.18 rpy=0 0 0 -> xyz=0 0 0.25 rpy=0 0 0
